# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SDRAM_MPU_INIT; DEBUG; CPU_MIMXRT1052DVL6A; PRINTF_FLOAT_ENABLE=1; __FPU_PRESENT=1
  ICCARM.CCIncludePath2: ../Source; ../Source/fmgen; ../Source/pmdwin; ../CMSIS/Include; ../devices; ../middleware/usb; ../middleware/usb/osa; ../middleware/usb/include; ../middleware/usb/device; ../middleware/usb/phy; ../middleware/sdmmc/src; ../middleware/sdmmc/inc; ../middleware/sdmmc/port; ../middleware/fatfs/src/fsl_sd_disk; ../middleware/fatfs/src; ../middleware/fatfs/src/option; ../devices/MIMXRT1052/drivers; ../devices/MIMXRT1052; ../devices/MIMXRT1052/utilities/io; ../devices/MIMXRT1052/utilities/str; ../devices/MIMXRT1052/utilities/log; ../devices/MIMXRT1052/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group board
    ../Source/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group drivers
    ../CMSIS/Include/: core_cm7.h
    ../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_usdhc.c fsl_usdhc.h
  group fatfs
    ../Source/: ffconf.h
  group fatfs/fatfs_include
    ../middleware/fatfs/src/: diskio.h ff.h integer.h
    ../middleware/fatfs/src/fsl_sd_disk/: fsl_sd_disk.h
  group fatfs/fatfs_source
    ../middleware/fatfs/src/: diskio.c ff.c
    ../middleware/fatfs/src/fsl_sd_disk/: fsl_sd_disk.c
  group sdmmc/inc
    ../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc/port
    ../middleware/sdmmc/port/usdhc/interrupt/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../middleware/sdmmc/port/: fsl_sdmmc_event.h
  group sdmmc/src
    ../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group startup
    ../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
    ../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
  group user
    ../Source/: fsl_wm8960.c main.c mainModule.cpp pmdmini.c
  group user/fmgen
    ../Source/fmgen/: compat.h diag.h file.cpp file.h fmgen.cpp fmgen.h fmgeninl.h fmgenx86.h fmtimer.cpp fmtimer.h headers.h misc.h opm.cpp opm.h opna.cpp opna.h psg.cpp psg.h types.h
  group user/pmdwin
    ../Source/pmdwin/: compat.h opnaw.cpp opnaw.h p86drv.cpp p86drv.h PCMMusDriver.h pmdwin.cpp pmdwin.h pmdwinimport.h ppsdrv.cpp ppsdrv.h ppz8l.cpp ppz8l.h table.cpp table.h util.cpp util.h
  group utilities
    ../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_notifier.c fsl_notifier.h fsl_shell.c fsl_shell.h
    ../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
